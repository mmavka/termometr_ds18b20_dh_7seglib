# IAR project dynamic_LED_thermostat_2DS18b20_iar_dh_ind.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x28
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1t-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m8a ATmega8A
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8a.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=$EXE_DIR$\fl_$PROJ_FNAME$.hex; -Ointel-standard,(XDATA)=$EXE_DIR$\ee_$PROJ_FNAME$.eep; -Oubrof7=$EXE_DIR$\u7_$PROJ_FNAME$.d90; -Oubrof8=$EXE_DIR$\u8_$PROJ_FNAME$.d90; -we183
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: main.c
  group 1-Wire
    1-Wire/: 1-wire.c
  group 7Seg
    7Seg/: indicator_2f.c
  group compilers
    compilers/: compilers.h
  group CRC
    CRC/: CRC.c
  group ds18b20
    ds18b20/: ds18b20.c
  group RTOS
    RTOS/: EERTOS.c EERTOSHAL.c HAL.c
  group serial
    serial/: serial.c serial.h
