<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dynamic_LED_thermostat_2DS18b20_iar_dh_ind.ewp</path>
  </project>
  <batchBuild/>
</workspace>


