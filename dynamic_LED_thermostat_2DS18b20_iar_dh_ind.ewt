<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>compilers</name>
    <file>
      <name>$PROJ_DIR$\compilers\compilers.h</name>
    </file>
  </group>
  <group>
    <name>RTOS</name>
    <file>
      <name>$PROJ_DIR$\RTOS\EERTOS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\RTOS\EERTOSHAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\RTOS\HAL.c</name>
    </file>
  </group>
  <group>
    <name>serial</name>
    <file>
      <name>$PROJ_DIR$\serial\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\serial\serial.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


